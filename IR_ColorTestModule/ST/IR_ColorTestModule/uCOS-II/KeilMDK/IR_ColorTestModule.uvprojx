# Keil uVision project IR_ColorTestModule.uvprojx, settings and files
target FLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CommunicationBridge +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,STM32F2XX,USE_STM322xG_EVAL
  c include: ..\..\uCOS-II;..\..\uCOS-II\KeilMDK;..\..\BSP;..\..\BSP\OS\uCOS-II;..\..\BSP\STM32F2xx\inc;..\..\BSP\CMSIS;..\..\BSP\CMSIS\Device_Support;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\..\..\uCOS-II\Source;..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\..\app;..\..\BSP\USB\App\inc;..\..\BSP\USB\STM32_USB_Device_Library\Core\inc;..\..\BSP\USB\STM32_USB_Device_Library\Class\cdc\inc;..\..\BSP\USB\STM32_USB_OTG_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./: app_cfg.h lib_cfg.h
    ../: app.c app_hooks.c cpu_cfg.h includes.h os_cfg.h
    ../../app/: ReadSensor.c LED_Color_Receiver.c ir_module.c ir_color_test.c ir_color_receiver.c ir_user_interface.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_ioe.c bsp_ioe.h bsp_lcd.c bsp_lcd.h bsp_ser.c bsp_ser.h bsp_w25q64.c bsp_sys.c bsp_i2c1.c bsp_can.c bsp_can.h bsp_io.c bsp_ser_1_IRDA.c bsp_i2c_1.c bsp_i2c_2.c bsp_i2c_3.c bsp_i2c_io.c bsp_aio.c
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/OS/uCOS-II/: bsp_os.c bsp_os.h
    ../../BSP/CMSIS/Device_Support/: system_stm32f2xx.c
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-II Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group STM32F2xx Library
    ../../BSP/STM32F2xx/inc/: misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
    ../../BSP/STM32F2xx/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group USB Drivers
    ../../BSP/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../../BSP/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../BSP/USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB App
    ../../BSP/USB/App/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c usb_it.c
